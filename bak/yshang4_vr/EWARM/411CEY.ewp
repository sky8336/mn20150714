# IAR project 411CEY.ewp, settings and files
configuration 411CEY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Src/Drivers; ../Src/Algo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 411CEY.bin
  ILINK.IlinkOutputFile: 411CEY.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
  group Application/User
    ../Src/: AlgorithmManager.c gpio.c i2c.c ipc.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c usb_otg.c
  group Application/User/Algo
    ../Src/Algo/: AccDynamicCali.c AccelerometerCalibrated.c AlsCalibrated.c BackupRegisters.c Barometer.c BiometricProximity.c CalibrationCommon.c CompassCalibrated.c CompassOrientation.c Conversion.c Debug.c DeviceOrientation.c DeviceOrientation6Axis.c DeviceOrientation9Axis.c Fusion.c GyroCalibrated.c GyroCalibrated6Axis.c Inclinometer.c MagDynamicCali.c Matrix.c MotionCompensation.c ownfinitenans.c PlatformCalibration.c Rotation.c Sensor.c Temperature.c TMR.c Vector.c
  group Application/User/Drivers
    ../Src/Drivers/: ak09911.c bma2x2.c bmg160.c bstdr_comm_support.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
